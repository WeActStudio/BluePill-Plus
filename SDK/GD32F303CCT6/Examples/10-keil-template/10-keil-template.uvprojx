# Keil uVision project 10-keil-template.uvprojx, settings and files
target 10-keil-template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 10-keil-template
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Src
    ./Src/: gd32f30x_it.c gpio.c main.c systick.c usart.c
target 10-keil-template HID IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: as above
  output: 10-keil-template HID-IAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,HID_IAP
  c include: .\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.4.0, Device:GD32F30x_StdPeripherals:ADC 2.1.0, Device:GD32F30x_StdPeripherals:GPIO 2.1.0, Device:GD32F30x_StdPeripherals:MISC 2.1.0, Device:GD32F30x_StdPeripherals:PMU 2.1.0, Device:GD32F30x_StdPeripherals:RCU 2.1.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_libopt 2.1.0, Device:Startup 2.1.0
