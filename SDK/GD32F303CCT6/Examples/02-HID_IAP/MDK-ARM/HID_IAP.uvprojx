# Keil uVision project HID_IAP.uvprojx, settings and files
target HID_IAP (6150000::V6.15::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HID_IAP +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\GD32\CMSIS;..\GD32\CMSIS\GD\GD32F30x\Include;..\GD32\GD32F30x_standard_peripheral\Include;..\GD32\GD32F30x_usbd_library\usbd\Include;..\GD32\GD32F30x_usbd_library\device\Include;..\GD32\GD32F30x_usbd_library\class\device\iap\Include;..\GD32\GD32F30x_usbd_library\class\device\hid\Include;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group APP
    ../Src/: main.c systick.c gpio.c gd32f30x_it.c gd32f30x_usbd_hw.c
    ../Inc/: usbd_conf.h
  group CMSIS
    ../GD32/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Startup
    ./: startup_gd32f30x_hd.s
  group GD32F30x_Peripherals
    ../GD32/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_fmc.c
  group USBD_Driver
    ../GD32/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../GD32/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../GD32/GD32F30x_usbd_library/class/device/iap/Source/: usb_iap_core.c
